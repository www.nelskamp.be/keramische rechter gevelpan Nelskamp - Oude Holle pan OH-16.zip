Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: test.ifc
Time: 2011-01-01T11:11:11
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.03 special version
Made in: example
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy: IFCBUILDINGELEMENTPROXY, keramische rechter gevelpan Nelskamp - Oude Holle pan OH-16
In: Default Building Storey
Description: Materiaal; Material: Default Material
BCB_Set_ifcbuildingelementproxy - WUID: AgAAAB2e7QABAAAAG_0AAAVWkAAAzUgAAHuoAACf8wAAHG4AAAAA; Hyperlink: http://bibliotheek.bouwconnect.nl/index.html?WUID=AgAAAB2e7QABAAAAG_0AAAVWkAAAzUgAAHuoAACf8wAAHG4AAAAA; aantal stuks per m²: 16 st; aanzichthoogte: 320 mm; breedte: 219.5 mm; dikte: 12.5 mm; golfhoogte: 41.5 mm; hoogte: 135 mm; lengte: 390 mm; merk: Nelskamp; NL-SfB tabel 3: g9; serie: Oude Holle pan OH-16; KOMO attest: yes; KOMO productcertificaat: yes; vorstbestendig: yes; soortelijke warmte: 840 j/kg·k; eenheid: st; uurloon: 38 euro
